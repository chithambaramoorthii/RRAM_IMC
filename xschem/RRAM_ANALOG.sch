v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 180 -80 0 0 {name=p2 lab=VDD_HIGH}
C {devices/iopin.sym} 180 -110 0 0 {name=p3 lab=VDD_LOW}
C {devices/opin.sym} 400 -80 0 0 {name=p20 lab=CSA[15:0]}
C {devices/ipin.sym} 90 -120 0 0 {name=p4 lab=V1_WL}
C {devices/ipin.sym} 90 -160 0 0 {name=p5 lab=V2_WL}
C {devices/ipin.sym} 90 -200 0 0 {name=p6 lab=V3_WL}
C {devices/ipin.sym} 90 -240 0 0 {name=p7 lab=V4_WL}
C {devices/ipin.sym} 90 -280 0 0 {name=p8 lab=IN1_WL[15:0]}
C {devices/ipin.sym} 90 -320 0 0 {name=p9 lab=IN0_WL[15:0]}
C {devices/ipin.sym} 90 -360 0 0 {name=p10 lab=ENABLE_SL}
C {devices/ipin.sym} 90 -400 0 0 {name=p11 lab=V1_SL}
C {devices/ipin.sym} 90 -440 0 0 {name=p12 lab=V2_SL}
C {devices/ipin.sym} 90 -480 0 0 {name=p13 lab=V3_SL}
C {devices/ipin.sym} 90 -520 0 0 {name=p14 lab=V4_SL}
C {devices/ipin.sym} 90 -560 0 0 {name=p15 lab=IN1_SL[15:0]}
C {devices/ipin.sym} 90 -600 0 0 {name=p16 lab=IN0_SL[15:0]}
C {devices/ipin.sym} 90 -640 0 0 {name=p17 lab=ENABLE_BL}
C {devices/ipin.sym} 90 -680 0 0 {name=p18 lab=V1_BL}
C {devices/ipin.sym} 90 -720 0 0 {name=p19 lab=V2_BL}
C {devices/ipin.sym} 90 -760 0 0 {name=p21 lab=V3_BL}
C {devices/ipin.sym} 90 -800 0 0 {name=p22 lab=V4_BL}
C {devices/ipin.sym} 90 -840 0 0 {name=p23 lab=IN1_BL[15:0]}
C {devices/ipin.sym} 90 -880 0 0 {name=p24 lab=IN0_BL[15:0]}
C {devices/ipin.sym} 90 -920 0 0 {name=p25 lab=ENABLE_CSA}
C {devices/ipin.sym} 90 -960 0 0 {name=p26 lab=V0_REF_ADC}
C {devices/ipin.sym} 90 -1000 0 0 {name=p27 lab=V1_REF_ADC}
C {devices/ipin.sym} 90 -1040 0 0 {name=p28 lab=V2_REF_ADC}
C {devices/ipin.sym} 90 -1080 0 0 {name=p29 lab=PRE}
C {devices/iopin.sym} 180 -140 0 0 {name=p33 lab=VSS}
C {devices/opin.sym} 400 -110 0 0 {name=p34 lab=ADC_OUT0[15:0]}
C {devices/opin.sym} 400 -140 0 0 {name=p35 lab=ADC_OUT1[15:0]}
C {devices/opin.sym} 400 -170 0 0 {name=p36 lab=ADC_OUT2[15:0]}
C {devices/ipin.sym} 90 -1120 0 0 {name=p30 lab=CLK_EN_ADC[1:0]}
C {devices/ipin.sym} 90 -1160 0 0 {name=p31 lab=REF_CSA}
C {devices/ipin.sym} 90 -1200 0 0 {name=p32 lab=SAEN_CSA}
C {devices/ipin.sym} 90 -80 0 0 {name=p1 lab=ENABLE_WL}
C {devices/iopin.sym} 180 -170 0 0 {name=p37 lab=VDD_PRE}
C {devices/iopin.sym} 180 -210 0 0 {name=p38 lab=SL}
