v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 100 -190 0 0 {name=p5 lab=clk}
C {devices/ipin.sym} 100 -230 0 0 {name=p6 lab=rst}
C {devices/iopin.sym} 190 -190 0 0 {name=p33 lab=VSS}
C {devices/opin.sym} 410 -190 0 0 {name=p35 lab=wishbone_data_out[31:0]}
C {devices/opin.sym} 410 -220 0 0 {name=p36 lab=ENABLE_WL}
C {devices/ipin.sym} 100 -270 0 0 {name=p1 lab=start_operation}
C {devices/ipin.sym} 100 -310 0 0 {name=p2 lab=wishbone_data_in[31:0]}
C {devices/ipin.sym} 100 -350 0 0 {name=p3 lab=wishbone_address_bus[31:0]}
C {devices/ipin.sym} 100 -390 0 0 {name=p4 lab=wbs_we_i}
C {devices/ipin.sym} 100 -430 0 0 {name=p7 lab=CSA[15:0]}
C {devices/ipin.sym} 100 -470 0 0 {name=p8 lab=ADC_OUT0[15:0]}
C {devices/ipin.sym} 100 -510 0 0 {name=p9 lab=ADC_OUT1[15:0]}
C {devices/ipin.sym} 100 -550 0 0 {name=p10 lab=ADC_OUT2[15:0]}
C {devices/ipin.sym} 100 -590 0 0 {name=p11 lab=ENABLE_CSA}
C {devices/ipin.sym} 100 -630 0 0 {name=p12 lab=rd_sync_fifo_output_buffer_ADC}
C {devices/ipin.sym} 100 -670 0 0 {name=p13 lab=rd_sync_fifo_output_buffer_CSA}
C {devices/iopin.sym} 190 -230 0 0 {name=p14 lab=vdd1v8}
C {devices/iopin.sym} 190 -270 0 0 {name=p15 lab=vdd3v3}
C {devices/opin.sym} 410 -250 0 0 {name=p16 lab=ENABLE_SL}
C {devices/opin.sym} 410 -280 0 0 {name=p17 lab=ENABLE_BL}
C {devices/opin.sym} 410 -310 0 0 {name=p18 lab=COL_SELECT}
C {devices/opin.sym} 410 -340 0 0 {name=p19 lab=PRE}
C {devices/opin.sym} 410 -370 0 0 {name=p20 lab=CLK_EN_ADC[1:0]}
C {devices/opin.sym} 410 -400 0 0 {name=p21 lab=SAEN_CSA}
C {devices/opin.sym} 410 -430 0 0 {name=p22 lab=IN0_WL[15:0]}
C {devices/opin.sym} 410 -460 0 0 {name=p23 lab=IN1_WL[15:0]}
C {devices/opin.sym} 410 -490 0 0 {name=p24 lab=IN0_BL[15:0]}
C {devices/opin.sym} 410 -520 0 0 {name=p25 lab=IN1_BL[15:0]}
C {devices/opin.sym} 410 -550 0 0 {name=p26 lab=IN0_SL[15:0]}
C {devices/opin.sym} 410 -580 0 0 {name=p27 lab=IN1_SL[15:0]}
